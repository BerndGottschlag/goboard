## firmware/main/boards/arm/goboard_nrf52840/Kconfig.board
```kconfig
config BOARD_GOBOARD_NRF52840
	bool "goboard (main keyboard) NRF52840"
	select HAS_DTS_GPIO
	depends on SOC_NRF52840_QIAA
```
